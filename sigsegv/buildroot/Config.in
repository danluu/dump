## sigsegv/buildroot/Config.in
```kconfig
config BR2_PACKAGE_SIGSEGV
	bool "sigsegv"
	help
	  This program causes a SIGSEGV by jumping to a bad location
```
